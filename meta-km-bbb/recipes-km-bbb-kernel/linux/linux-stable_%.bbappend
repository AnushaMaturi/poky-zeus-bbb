FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"
SRC_URI += "file://0005-Enter-Switch-GPIO11-Raising-Edge-Interrupt-porting-o.patch \
            file://0001-Up-and-Down-Switchs-GPIO26-and-27-Falling-Edge-Inter.patch \
"
